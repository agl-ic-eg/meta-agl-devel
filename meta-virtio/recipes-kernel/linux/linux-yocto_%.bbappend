require ${@bb.utils.contains('AGL_FEATURES', 'agl-virtio', 'linux-yocto_agl-virtio.inc', '', d)}
