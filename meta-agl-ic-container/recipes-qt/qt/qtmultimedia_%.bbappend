#PACKAGECONFIG:append = " alsa"
#PACKAGECONFIG:remove = "ffmpeg pulseaudio"
