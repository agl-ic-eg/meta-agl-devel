IMAGE_INSTALL:append = " \
     linux-firmware-rtl8822 \
     linux-firmware-rtl8125 \
     rockchip-libmali-firmware \
"
