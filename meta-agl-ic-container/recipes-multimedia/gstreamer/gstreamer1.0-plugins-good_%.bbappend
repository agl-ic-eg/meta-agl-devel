PACKAGECONFIG:append = " \
    pulseaudio \
"
