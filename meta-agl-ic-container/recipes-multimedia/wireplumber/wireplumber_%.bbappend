FILESEXTRAPATHS:prepend := "${THISDIR}/wireplumber:"

SRC_URI += "\
    file://0001-systemd-wireplumber-to-not-depend-on-the-pipewire-de.patch \
"
