# remote display setup
PACKAGECONFIG:append:agl-rdp = " rdp"
