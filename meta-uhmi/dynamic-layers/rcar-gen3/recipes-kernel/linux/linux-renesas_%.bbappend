require recipes-kernel/linux/linux-rvgpu.inc
