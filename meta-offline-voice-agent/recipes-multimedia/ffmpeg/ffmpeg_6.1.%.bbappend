require ${@bb.utils.contains('AGL_FEATURES', 'whisper', 'ffmpeg_metawhisper.inc', '', d)}
