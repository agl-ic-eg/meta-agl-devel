SUMMARY = "C version of reader, parser and emitter for ruamel.yaml"
HOMEPAGE = "https://sourceforge.net/projects/ruamel-yaml-clib/"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=1debc1593104ded7e88b0ac5659af552"

PYPI_PACKAGE = "ruamel.yaml.clib"

SRC_URI[md5sum] = "b72e549363fa1b9c4f9123e98f2b46cc"
SRC_URI[sha256sum] = "beb2e0404003de9a4cab9753a8805a8fe9320ee6673136ed7f04255fe60bb512"

inherit pypi setuptools3
