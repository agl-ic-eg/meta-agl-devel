SUMMARY = "A python binding for crfsuite"

HOMEPAGE = "https://github.com/scrapinghub/python-crfsuite"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=0a36d267a3ece77cbc8ebc95ca7e2edd"

PYPI_PACKAGE = "python-crfsuite"

SRC_URI[md5sum] = "2765b8401c63a8f970be73a0c2ca04bf"
SRC_URI[sha256sum] = "f38524631e2b533341f10f2c77689270dc6ecd5985495dccf7aa37b1045bc2e5"

inherit pypi setuptools3
