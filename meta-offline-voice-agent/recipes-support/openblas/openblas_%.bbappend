# remove openmp from PACKAGECONFIG
PACKAGECONFIG:remove = "openmp"
