require ${@bb.utils.contains('AGL_FEATURES', 'agl-drm-lease', 'weston_agl-drm-lease.inc', '', d)}
