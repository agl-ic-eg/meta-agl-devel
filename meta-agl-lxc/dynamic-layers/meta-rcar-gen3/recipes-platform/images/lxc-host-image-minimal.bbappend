IMAGE_INSTALL += " \
    bosch-iccom \
"
