BRANCH = "dev"
SRC_URI = "git://github.com/agl-ic-eg/cluster-refgui.git;protocol=git;branch=${BRANCH} \
           file://cluster.service \
"
SRCREV = "f84942bec3c0b8c85331bc70919220983634babb"
